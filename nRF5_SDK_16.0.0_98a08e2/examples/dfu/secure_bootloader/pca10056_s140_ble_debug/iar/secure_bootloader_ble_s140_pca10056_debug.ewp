# IAR project secure_bootloader_ble_s140_pca10056_debug.ewp, settings and files
configuration nrf52840_xxaa_s140 (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=2; NRF_DFU_SVCI_ENABLED; NRF_SD_BLE_API_VERSION=7; S140; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\components\ble\common; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\log; ..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\..\..\external\fprintf; ..\..\..\..\..\external\nano-pb; ..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\external\nrf_cc310_bl\include; ..\..\..\..\..\external\nrf_oberon; ..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\integration\nrfx; ..\..\..\..\..\modules\nrfx; ..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure_bootloader_ble_s140_pca10056_debug.hex
  ILINK.IlinkOutputFile: secure_bootloader_ble_s140_pca10056_debug.out
  ILINK.IlinkIcfFile: secure_bootloader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_Crypto backend CC310_BL
    ../../../../../components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nRF_Oberon_Crypto
    ../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_3.0.6.a
  group nRF_SoftDevice
    ../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Drivers
    ../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Crypto
    ../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group Application
    ../../../: dfu_public_key.c
    ../../: main.c
    ../config/: sdk_config.h
  group nRF_SVC
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../../../components/libraries/svc/: nrf_svc_handler.c
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group None
    ../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_DFU
    ../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../../../../../components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_srv_common.c
  group nrf_cc310_bl
    ../../../../../external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: libnrf_cc310_bl_0.9.13.a
  group nRF_Crypto backend Oberon
    ../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
